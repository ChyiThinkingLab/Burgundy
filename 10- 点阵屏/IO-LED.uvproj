# Keil uVision project IO-LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: OUT_STC51_Hex +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\delay;.\GPIO;.\Timer;.\LED_Display
  group Source Group 1
    ./: main.c
    ./Timer/: timer.c
    ./GPIO/: GPIO.c
    ./delay/: delay.c
    ./LED_Display/: led_display.c
